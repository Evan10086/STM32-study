# Keil uVision project project.uvprojx, settings and files
target spi (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\;.\RTE;.\RTE\Device\STM32F407ZG;.\user;.\hardware\led;.\hardware\mfrc522;.\hardware\usart;.\hardware\w25qxx;.\hardware\key;.\hardware\rtc;.\hardware\beep;.\hardware\pwm
  asm include: .\RTE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/: main.c delay.c
    ./hardware/usart/: usart.c
  group hardware
    ./hardware/mfrc522/: MFRC522.c
    ./hardware/w25qxx/: w25qxx.c
    ./hardware/led/: led.c
    ./hardware/key/: key.c
    ./hardware/rtc/: rtc.c
    ./hardware/beep/: beep.c
    ./hardware/pwm/: pwm.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
